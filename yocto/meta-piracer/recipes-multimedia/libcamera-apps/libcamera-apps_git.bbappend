# rpicam_app.so.x.y.z versioned library is installed but missing from FILES in meta-raspberrypi
FILES:${PN} += "${libdir}/rpicam_app.so.*"
